# Keil uVision project TIMER.uvprojx, settings and files
target TIMER (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: yy5 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER CHAR_CODE
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\lcd12864;..\HARDWARE\iic;..\HARDWARE\BMP180;..\HARDWARE\MAX6675;..\HARDWARE\uart1;..\HARDWARE\ADC;..\HARDWARE\GP2Y;..\HARDWARE\SPI;..\HARDWARE\AMME;..\HARDWARE\USART;..\HARDWARE\BC95;..\HARDWARE\RELAY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/lcd12864/: LCD12864.c
    ../HARDWARE/BMP180/: BMP180.c IIC.c
    ../HARDWARE/MAX6675/: MAX6675.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/GP2Y/: GP2Y.c
    ../HARDWARE/AMME/: db_amme.c
    ../HARDWARE/BC95/: bc95.c
    ../HARDWARE/RELAY/: relay.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c misc.c stm32f10x_tim.c stm32f10x_adc.c
